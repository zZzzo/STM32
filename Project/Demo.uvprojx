# Keil uVision project Demo.uvprojx, settings and files
target Demo (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libaries\CMSIS;..\Libaries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\LED;..\User\KEY;..\User\SysTick;..\User\RCC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Libaries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libaries/CMSIS/: system_stm32f10x.c
  group Libaries
    ../Libaries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group RCC
    ../User/RCC/: sys_rcc.c
  group Systick
    ../User/SysTick/: SysTick.c
  group LED
    ../User/LED/: led_driver.c
  group KEY
    ../User/KEY/: key_driver.c
  group User
    ../User/: stm32f10x_it.c main.c
  group Doc
    ../Doc/: Readme.txt
